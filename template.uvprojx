# Keil uVision project template.uvprojx, settings and files
target Application (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=2
  c include: .\Core;.\Core\CMSIS;.\Driver\inc;.\HAL\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\Library\mem;.\Library\debug;.\Library\fat\inc;.\Component\button;.\Component\button\include;.\Component\flash;.\Component\flash\include;.\Component\led;.\Component\led\include;.\Component\ring_buffer;.\Component\ring_buffer\include;.\Library\embed_graphic;.\Library\embed_graphic\gfx_hal;.\Library\embed_graphic\gfx_core;.\Library\embed_graphic\gfx_draw;.\Library\embed_graphic\gfx_widget;.\Library\embed_graphic\gfx_common;.\Library\embed_graphic\gfx_driver\lcd;.\Library\embed_graphic\gfx_driver\lcd\st7735;.\Library\embed_graphic\gfx_driver\lcd\ili9341;.\Library\embed_graphic\gfx_driver\oled\ssd1306;.\Library\embed_graphic\gfx_fonts\arial_regular
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/: main.c stm32_interrupt.c
  group Startup
    ./Core/Startup/: startup_stm32f10x_md.s
  group Component
    ./Component/button/: button.c
    ./Component/flash/: spiflash.c
    ./Component/led/: led_rgb.c
    ./Component/ring_buffer/: uart_ring_buffer.c
  group Driver
    ./Driver/src/: stm32_driver_i2c.c stm32_driver_uart.c stm32_driver_tim.c stm32_driver_rcc.c stm32_driver_spi.c stm32_driver_gpio.c stm32_driver_adc.c
  group HAL
    ./HAL/src/: stm32_hal_i2c.c stm32_hal_spi.c stm32_hal_usb.c stm32_usb_cdc.c stm32_usb_desc.c stm32_usb_hid.c
  group Library
    ./Library/fat/src/: ff.c sdmm.c
    ./Library/mem/: mem.c tlsf.c
    ./Library/debug/: debug.c
  group Graphic
    ./Library/embed_graphic/gfx_common/: gfx_alloc.c gfx_area.c gfx_font.c gfx_ll.c gfx_text.c
    ./Library/embed_graphic/gfx_core/: gfx_obj.c gfx_refr.c gfx_style.c gfx_task.c gfx_vdb.c
    ./Library/embed_graphic/gfx_draw/: gfx_draw.c gfx_draw_label.c gfx_draw_rect.c
    ./Library/embed_graphic/gfx_hal/: gfx_hal_tick.c
    ./Library/embed_graphic/gfx_widget/: gfx_button.c gfx_label.c
    ./Library/embed_graphic/gfx_driver/lcd/st7735/: st7735.c
    ./Library/embed_graphic/gfx_driver/lcd/ili9341/: ili9341.c
    ./Library/embed_graphic/gfx_driver/lcd/: lcd_generic.c
  group Fonts
    ./Library/embed_graphic/gfx_fonts/arial_regular/: arial_regular_4.c arial_regular_8.c arial_regular_14.c
